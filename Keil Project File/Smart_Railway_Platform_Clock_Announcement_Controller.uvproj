# Keil uVision project Smart_Railway_Platform_Clock_Announcement_Controller.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Smart_Railway_Clock_Announcement_Controller +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s buzzer.c delay.c eint_interrupt.c kpm.c lcd.c led.c menu.c rtc.c train_db.c train_info_display.c main.c
